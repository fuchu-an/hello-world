addtask build

