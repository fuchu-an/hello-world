## meta-hello/conf/layer.conf
```bitbake
BBPATH .= ":${LAYERDIR}"
BBFILES += "${LAYERDIR}/*.bb"
BBFILE_COLLECTIONS += "meta-hello"
BBFILE_PATTERN_meta-hello := "^${LAYERDIR_RE}/"
```
